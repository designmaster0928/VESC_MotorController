# Repository designmaster0928/VESC_MotorController

## KiCad design REFER/Basic/bldc-hardware-master/design/BLDC_4.kicad_pcb

Board: 4 copper layers, 38.5 x 65.0 mm, 126 parts (68 on the bottom side), 96 nets.

Parts:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin
C1, C8, C9, C39, C40, C43, C44, C49: 10u,50V; SMD-1206
C2, C3, C27, C32: 100n; SMD-0603_c
C4, C5, C6, C7: 4n7; SMD-0603_c
C10, C11, C12, C13, C14, C16, C17, C18, C20, C23, C24, C26, C31, C35, C41, C52, C401: 2.2u; SMD-0603_c
C15, C38: 15p; SMD-0603_c
C19: 120p; SMD-0603_c
C21: 6.8n; SMD-0603_c
C22: 22n; SMD-0603_c
C25, C33: 100u; c_tant_B
C28, C29, C30: 220n; SMD-0603_c
C34, C36: 2.2n; SMD-0603_c
C37: 15u,100V; c_2220
C51: 15u, 100v; c_2220
D1: GREEN; LED-0603
D2: RED; LED-0603
D3: LED; LED-0603
D4: DIODESCH; SMA_Handsoldering
D5: TVS 5V; do214ac
K1: SERVO; pinhead-1X03
L1: 22u; inductor_smd_8x5mm
P1: HALL/Encoder; MICRO_JST_6
P2: SWD; MICRO_JST_6
P3: PWR_COMM; b7b-ph-kl
P4: IN+; 1PAD_4x5mm
P5: IN-; 1PAD_4x5mm
P6: MOTOR1; 1PAD_4x5mm
P7: MOTOR2; 1PAD_4x5mm
P9: MOTOR3; 1PAD_4x5mm
P101: CANBUS; b4b-ph-kl
Q1, Q2, Q3, Q4, Q5, Q6: IRFS7530; D2PAK-7-GDS
R1: NTC 10k; SMD-0603_r
R2, R7, R8, R9, R10, R20, R402: 10k; SMD-0603_r
R3, R23, R26, R30, R32, R36, R46: 39k; SMD-0603_r
R4, R5, R11, R12, R13, R22, R24, R27, R33: 2k2; SMD-0603_r
R6: 0R; SMD-0603_r
R17: 18k; SMD-0603_r
R18: 3k3; SMD-0603_r
R19: 15k; SMD-0603_r
R21: 220k; SMD-0603_r
R25: 1M; SMD-0603_r
R28, R29, R34, R35, R42, R43: 4R7; SMD-0603_r
R37, R38, R48, R49, R50, R51: 100R; SMD-0603_r
R53, R54: SHUNT; WSLP2726
R103, R104: 22R; SMD-0603_r
R401: NI; SMD-0603_r
U1: STM32F40X_LQFP64; lqfp64_pad_mod
U2: TC2117; SOT-223
U3: DRV8302; TSSOP-56-PP
U401: SN65HVD232; SOIC-8-W
X1: MINI-USB-SHIELD-32005-201; USB-UX60R-MB-5ST
X2: 8MHz 10ppm; Crystal_5x3mm

Connections:
+5V: C33.1, D5.2, K1.2, L1.2, P1.1, P3.1, P101.4, R6.2, R17.1, U2.3
/CAN bus transceiver/CANH: P101.3, R401.1, U401.7
/CAN bus transceiver/CANL: P101.2, R401.2, U401.6
/CAN bus transceiver/CAN_RX: U1.61, U401.4
/CAN bus transceiver/CAN_TX: U1.62, U401.1
/Filters/HALL1_IN: P1.3, R8.1, R13.1
/Filters/HALL1_OUT: C7.1, R8.2, U1.58
/Filters/HALL2_IN: P1.4, R9.1, R12.1
/Filters/HALL2_OUT: C6.1, R9.2, U1.59
/Filters/HALL3_IN: P1.5, R10.1, R11.1
/Filters/HALL3_OUT: C5.1, R10.2, U1.52
/Filters/TEMP_IN: C4.2, P1.2, R7.1, U1.8
/MCU/ADC_TEMP: C41.1, R1.2, R2.1, U1.17
/MCU/AN_IN: C2.2, R3.2, R4.2, U1.10
/MCU/BR_SO1: U1.27, U3.25
/MCU/BR_SO2: U1.26, U3.26
/MCU/DC_CAL: U1.33, U3.12
/MCU/EN_GATE: U1.51, U3.16
/MCU/FAULT: U1.53, U3.6
/MCU/H1: U1.43, U3.17
/MCU/H2: U1.42, U3.19
/MCU/H3: U1.41, U3.21
/MCU/L1: U1.36, U3.18
/MCU/L2: U1.35, U3.20
/MCU/L3: U1.34, U3.22
/MCU/LED_GREEN: R37.2, U1.24
/MCU/LED_RED: R38.2, U1.25
/MCU/MISO_ADC_EXT2: P3.7, U1.22
/MCU/RX_SCL_MOSI: P3.6, U1.23, U1.29, U1.38
/MCU/SCK_ADC_EXT: P3.4, U1.21
/MCU/SENS1: R23.2, R24.2, U1.16
/MCU/SENS2: R26.2, R27.2, U1.15
/MCU/SENS3: R32.2, R33.2, U1.14
/MCU/SERVO: C3.2, R5.1, U1.57
/MCU/TX_SDA_NSS: P3.5, U1.20, U1.30, U1.37
/MCU/USB_DM: R103.1, U1.44
/MCU/USB_DP: R104.1, U1.45
/Mosfet driver/H1_LOW: Q2.S, R30.1, R36.1, R53.2, U3.44
/Mosfet driver/H1_VS: C28.1, P9.1, Q1.S, Q2.D, R32.1, U3.46
/Mosfet driver/H2_VS: C29.1, P7.1, Q3.S, Q4.D, R26.1, U3.41
/Mosfet driver/H3_LOW: Q6.S, R46.1, R54.1, U3.34
/Mosfet driver/H3_VS: C30.1, P6.1, Q5.S, Q6.D, R23.1, U3.36
/Mosfet driver/M_H1: R28.2, U3.47
/Mosfet driver/M_H2: R34.2, U3.42
/Mosfet driver/M_H3: R42.2, U3.37
/Mosfet driver/M_L1: R29.2, U3.45
/Mosfet driver/M_L2: R35.2, U3.40
/Mosfet driver/M_L3: R43.2, U3.35
/Mosfet driver/SH1_A: R48.1, R54.3
/Mosfet driver/SH1_B: R49.1, R54.4
/Mosfet driver/SH2_A: R50.1, R53.4
/Mosfet driver/SH2_B: R51.1, R53.3
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C19.1, C20.1, C21.1, C23.1, C24.2, C25.2, C26.2, C31.1, C32.1, C33.2, C35.1, C37.1, C38.2, C39.1, C40.1, C41.2, C43.2, C44.2, C49.2, C51.1, C52.1, C401.2, D1.2, D2.2, D3.2, D4.1, D5.1, K1.3, P1.6, P2.3, P3.3, P5.1, P101.1, Q4.S, R2.2, R4.1, R18.2, R20.2, R21.1, R24.1, R25.1, R27.1, R33.1, R53.1, R54.2, R402.2, U1.12, U1.18, U1.60, U1.63, U2.1, U3.8, U3.10, U3.28, U3.39, U3.57, U401.2, X1.5, X2.3
NRST: C32.2, P2.5, U1.7
unnamed: C15.1, U1.5, X2.1
unnamed: C16.1, U1.31
unnamed: C17.1, U1.47
unnamed: C18.1, C26.1, U3.13
unnamed: C19.2, R19.2, U3.2
unnamed: C20.2, C52.2, U3.11, U3.23
unnamed: C21.2, R19.1
unnamed: C22.1, U3.14
unnamed: C22.2, U3.15
unnamed: C23.2, U3.27
unnamed: C27.1, D4.2, L1.1, U3.50, U3.51
unnamed: C27.2, U3.52
unnamed: C28.2, U3.48
unnamed: C29.2, U3.43
unnamed: C30.2, U3.38
unnamed: C34.1, R48.2, U3.33
unnamed: C34.2, R49.2, U3.32
unnamed: C36.1, R50.2, U3.31
unnamed: C36.2, R51.2, U3.30
unnamed: C38.1, U1.6, X2.2
unnamed: D1.1, R37.1
unnamed: D2.1, R38.1
unnamed: D3.1, R22.1
unnamed: K1.1, R5.2
unnamed: Q1.G, R28.1
unnamed: Q2.G, R29.1, R30.2
unnamed: Q3.G, R34.1
unnamed: Q4.G, R35.1, R36.2
unnamed: Q5.G, R42.1
unnamed: Q6.G, R43.1, R46.2
unnamed: R6.1, X1.1
unnamed: R17.2, R18.1, U3.3
unnamed: R20.1, U3.7
unnamed: R21.2, U3.1
unnamed: R25.2, U3.49
unnamed: R103.2, X1.2
unnamed: R104.2, X1.3
unnamed: R402.1, U401.8
SWCLK: P2.2, U1.49
SWDIO: P2.4, U1.46
VCC: C10.2, C11.2, C12.2, C13.2, C14.2, C24.1, C25.1, C31.2, C35.2, C401.1, P2.1, P3.2, R1.1, R7.2, R11.2, R12.2, R13.2, R22.2, U1.1, U1.13, U1.19, U1.32, U1.48, U1.64, U2.2, U3.9, U3.24, U401.3
V_SUPPLY: C1.2, C8.2, C9.2, C37.2, C39.2, C40.2, C43.1, C44.1, C49.1, C51.2, P4.1, Q1.D, Q3.D, Q5.D, R3.1, U3.29, U3.53, U3.54

## Commit log

2023-08-03 first step
2023-08-04 third step
2023-08-04 fourth step
2023-08-10 step11
2023-08-10 step12
2023-08-11 sterp15
2023-08-16 work-8.16-1
2023-08-17 work-8.17-1
2023-08-17 work-8.18-1
2023-08-18 work-8.18-2
2023-08-21 work-8.21-1
2023-08-23 work-8.22-1
2023-08-25 work-8.25-1
2023-08-31 work-8.30-1
2023-09-05 work-9.5-1
2023-10-01 Addied-23/10/01
